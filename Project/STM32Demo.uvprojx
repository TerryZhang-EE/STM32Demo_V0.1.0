# Keil uVision project STM32Demo.uvprojx, settings and files
target STM32Demo (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32Demo +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\Startup;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\BSP;..\API;..\APP;..\UI;..\METHOD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Libraries/Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/: bsp_bsp.h bsp_gpio_conf.h bsp_tim_conf.h bsp_uart_conf.h
    ../BSP/bsp_led/: bsp_led.c
    ../BSP/bsp_sys/: bsp_sys.c
    ../BSP/bsp_sys_tim/: bsp_sys_tim.c
  group API
    ../API/api_main/: api_main.c
  group APP
    ../APP/app_main/: app_main.c
  group UI
    ../UI/ui_main/: ui_main.c
  group METHOD
    ../Method/method_main/: method_main.c
